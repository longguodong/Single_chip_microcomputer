# Keil uVision project lanqiaobei.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: lanqiaobei +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c delay.c scq.c ds18b20.c display.c keybord.c ds1302.c iic.c lcd.c
